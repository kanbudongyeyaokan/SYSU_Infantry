/**
 * @file    decision_making.c
 * @brief   鍐崇瓥浠诲姟
 * @author  SYSU鐢垫帶缁? * @date    2025-09-17
 * @version 1.0
 * 
 * @note    鍐崇瓥鎺у埗妯″紡锛屾帶鍒堕噺锛屽苟浼犻€佸埌瀵瑰簲鐨勪换鍔? */
#include "decision_making.h"
//閫氫俊
#include "message_center.h"
//鐘舵€佹満鑾峰彇
#include "robot_definitions.h"
//閬ユ帶鍣ㄦ帶鍒?#include <stdio.h>
#include "remote_control.h"
#include "main.h"
#include <stdbool.h>
#include <math.h>



/**********************鍙戝嚭鍐崇瓥淇℃伅***************************/
//瀛樺偍閬ユ帶鍣ㄦ暟鎹紝CURRENT-褰撳墠鏁版嵁,LAST-涓婁竴娆℃暟鎹?static RC_ctrl_t *rc_data;

//搴曠洏鎺у埗妯″紡/鎺у埗閲忓彂甯?static Publisher_t *chassis_cmd_pub;        //搴曠洏鎺у埗淇℃伅鍙戝竷鑰?static Chassis_cmd_send_t chassis_cmd_send;//瀛樺偍鍐崇瓥灞傜粰搴曠洏搴旂敤灞傜殑鎺у埗淇℃伅

//浜戝彴鎺у埗妯″紡/鎺у埗閲忓彂甯?static Publisher_t *gimbal_cmd_pub;          //浜戝彴鎺у埗淇℃伅鍙戝竷鑰?static Gimbal_cmd_send_t  gimbal_cmd_send;  //瀛樺偍鍐崇瓥灞傜粰浜戝彴搴旂敤灞傜殑鎺у埗淇℃伅

//鍙戝皠鏈烘瀯鎺у埗妯″紡/鎺у埗閲忓彂甯?static Publisher_t *shoot_cmd_pub;           //鍙戝皠鏈烘瀯鎺у埗淇℃伅鍙戝竷鑰?static Shoot_cmd_send_t   shoot_cmd_send;   //瀛樺偍鍐崇瓥灞傜粰鍙戝皠鏈烘瀯搴旂敤灞傜殑鎺у埗淇℃伅

//鏈哄櫒浜烘暣浣撳伐浣滅姸鎬侊紙浜屽厓锛夛細----ON锛氬湪绾?OFF锛氱绾?static Robot_status_e robot_state = ROBOT_OFF;

/************************************************************/

/**********************鎺ユ敹鍙嶉淇℃伅***************************/
//搴曠洏鍙嶉鏁版嵁璇诲彇
static Subscriber_t *chassis_feedback_sub;               //搴曠洏鍙嶉淇℃伅璁㈤槄鑰?static Chassis_feedback_info_t chassis_feedback_recv;   //瀛樺偍搴曠洏搴旂敤灞傚彂缁欏喅绛栧眰鐨勪俊鎭?
//浜戝彴鍙嶉鏁版嵁璇诲彇
static Subscriber_t *gimbal_feedback_sub;                //浜戝彴鍙嶉淇℃伅璁㈤槄鑰?static Gimbal_feedback_info_t  gimbal_feedback_recv;    //瀛樺偍浜戝彴搴旂敤灞傚彂缁欏喅绛栧眰鐨勪俊鎭?
static bool gimbal_yaw_initialized = false;


//鍙戝皠鏈烘瀯鍙嶉鏁版嵁璇诲彇
static Subscriber_t *shoot_feedback_sub;                 //鍙戝皠鍙嶉淇℃伅璁㈤槄鑰?static Shoot_feedback_info_t   shoot_feedback_recv;     //瀛樺偍鍙戝皠搴旂敤灞傚彂缁欏喅绛栧眰鐨勪俊鎭?/************************************************************/

/**
 * @brief 浠诲姟鍒濆鍖栧嚱鏁帮紝鍒濆鍖栧喅绛栧眰鐨勫彂甯冭€呭拰璁㈤槄鑰?鑾峰彇閬ユ帶鍣ㄦ暟鎹? *
*/
void Decision_making_task_init()
{
    //鎺ユ敹閬ユ帶鍣ㄦ暟鎹?    rc_data = RC_Data_Get(&huart3);  // 淇敼涓哄搴斾覆鍙?娉ㄦ剰濡傛灉鏄嚜鐮旀澘dbus鍗忚涓插彛闇€閫夌敤娣诲姞浜嗗弽鐩稿櫒鐨勯偅涓?
    /***********************************鍒濆鍖栧喅绛栧眰鐨勫彂甯冭€呭拰璁㈤槄鑰?**************************************/
    //搴曠洏
    chassis_cmd_pub = Pub_register("chassis_cmd",sizeof(Chassis_cmd_send_t));
    chassis_feedback_sub = Sub_register("chassis_feedback", sizeof(Chassis_feedback_info_t));//搴曠洏鍙嶉鏁版嵁璁㈤槄鑰?    //浜戝彴
    gimbal_cmd_pub = Pub_register("gimbal_cmd", sizeof(Gimbal_cmd_send_t));//浜戝彴娉ㄥ唽鐨勮瘽棰樻槸gimbal_cmd
    gimbal_feedback_sub = Sub_register("gimbal_feedback", sizeof(Gimbal_feedback_info_t));
    //鍙戝皠鏈烘瀯
    shoot_cmd_pub = Pub_register("shoot_cmd", sizeof(Shoot_cmd_send_t));
    shoot_feedback_sub = Sub_register("shoot_feedback", sizeof(Shoot_feedback_info_t));

    //鏈哄櫒浜哄紑濮嬪伐浣?    robot_state = ROBOT_ON;

    gimbal_cmd_send.yaw = 0.0f;
    gimbal_cmd_send.pitch = 0.0f;
    gimbal_yaw_initialized = false;
    chassis_cmd_send.gimbal_yaw_total_angle = 0.0f;
    chassis_cmd_send.gimbal_yaw_rate = 0.0f;

}

void Receive_feedback_infomation()
{
    //鑾峰彇搴曠洏鍙嶉淇℃伅
    Sub_get_message(chassis_feedback_sub,(void *)(&chassis_feedback_recv));
    //鑾峰彇浜戝彴鍙嶉淇℃伅
    Sub_get_message(gimbal_feedback_sub,(void *)(&gimbal_feedback_recv));
    if (!gimbal_yaw_initialized)
    {
        gimbal_cmd_send.yaw = gimbal_feedback_recv.yaw_motor_total_angle;
        gimbal_yaw_initialized = true;
    }
    //鑾峰彇鍙戝皠鏈烘瀯鍙嶉淇℃伅
    Sub_get_message(shoot_feedback_sub,(void *)(&shoot_feedback_recv));
}

void Send_command_to_all_task()
{
    //鍙戦€佸簳鐩樻帶鍒朵俊鎭?    Pub_push_message(chassis_cmd_pub,(void *)(&chassis_cmd_send));
    //鍙戦€佷簯鍙版帶鍒朵俊鎭?    Pub_push_message(gimbal_cmd_pub,(void *)(&gimbal_cmd_send));
    //鍙戦€佸彂灏勬満鏋勬帶鍒朵俊鎭?    Pub_push_message(shoot_cmd_pub,(void *)(&shoot_cmd_send));
}

/**
 * @brief 鏍规嵁閬ユ帶鍣ㄥ乏杈瑰紑鍏冲喅瀹氭満鍣ㄤ汉鏄敭榧犳帶鍒惰繕鏄仴鎺у櫒鎺у埗,骞朵笖璋冪敤瀵瑰簲鐨勬帶鍒跺嚱鏁? *
*/
void Robot_set_command()
{
    //printf("rc_data[CURRENT].rc.Rrocker_x:%d\r\n",rc_data[CURRENT].rc.Rrocker_x);
    //printf("rc_data[CURRENT].rc.Rrocker_y:%d\r\n",rc_data[CURRENT].rc.Rrocker_y);
    //printf("rc_data[CURRENT].rc.Lrocker_x:%d\r\n",rc_data[CURRENT].rc.Lrocker_x);
    //printf("rc_data[CURRENT].rc.Lrocker_y:%d\r\n",rc_data[CURRENT].rc.Lrocker_y);
    // printf("rc_data[CURRENT].rc.dial:%d\r\n",rc_data[CURRENT].rc.dial);
    //printf("rc_data[CURRENT].rc.Lswitch:%d\r\n",rc_data[CURRENT].rc.Lswitch);
    //printf("rc_data[CURRENT].rc.Rswitch:%d\r\n",rc_data[CURRENT].rc.Rswitch);
     //宸﹁竟寮€鍏虫墦涓嬶紝杩涘叆閬ユ帶鍣ㄦ帶鍒舵ā寮?   if (rc_data[CURRENT].rc.Lswitch == SWITCH_IS_DOWN)
   {
        RC_ctrl_set();
    }
    //宸﹁竟寮€鍏虫墦涓婏紝杩涘叆鍗曞彂妯″紡
      else if (rc_data[CURRENT].rc.Lswitch == SWITCH_IS_UP)
    {
        Keyboard_ctrl_set();
    } 
}

/**
 * @brief 鎺у埗杈撳叆涓洪仴鎺у櫒(璋冭瘯鏃?鐨勬ā寮忓拰鎺у埗閲忚缃? *
*/
void RC_ctrl_set()
{
    /**鏍规嵁閬ユ帶鍣ㄥ紑鍏崇姸鎬佽瀹氭ā寮?*/
   // printf("RC_ctrl_set \n");
    /**搴曠洏/浜戝彴妯″紡璁惧畾**/
    //濡傛灉鍙宠竟寮€鍏虫墦涓嬶紝鍒欒繘鍏ュ簳鐩樿窡闅忎簯鍙版ā寮?浜戝彴杩涘叆闄€铻轰华鍙嶉妯″紡
    if (rc_data[CURRENT].rc.Rswitch == SWITCH_IS_DOWN)
    {
        chassis_cmd_send.chassis_mode = CHASSIS_FOLLOW_GIMBAL;
        gimbal_cmd_send.gimbal_mode = GIMBAL_GYRO_MODE; 
    }
    //濡傛灉鍙宠竟寮€鍏虫墦涓婏紝鍒欒繘鍏ュ簳鐩樿嚜鐢辨ā寮忥紝姝ゆ椂搴曠洏涓嶈窡闅忎簯鍙?    else if (rc_data[CURRENT].rc.Rswitch == SWITCH_IS_MID)
    {
        chassis_cmd_send.chassis_mode = CHASSIS_NO_FOLLOW;
        gimbal_cmd_send.gimbal_mode = GIMBAL_GYRO_MODE;  
    }
    //濡傛灉鍙宠竟寮€鍏虫墦涓棿锛屽垯搴曠洏杩涘叆灏忛檧铻烘ā寮忥紝浜戝彴杩涘叆鑷敱妯″紡
    else if (rc_data[CURRENT].rc.Rswitch == SWITCH_IS_UP)
    {
        chassis_cmd_send.chassis_mode = CHASSIS_ROTATE;
        gimbal_cmd_send.gimbal_mode = GIMBAL_GYRO_MODE;
    }
    /**灏勫嚮妯″紡璁惧畾**/
    //宸﹁竟鎷ㄨ疆寰€涓婃墦寮€鍚懇鎿﹁疆,杩涘叆鍑嗗灏勫嚮妯″紡
    if (rc_data[CURRENT].rc.dial > 150)
    {
        shoot_cmd_send.shoot_mode = SHOOT_ON;
    }
    //姝ｅ父鎯呭喌涓嬩笉鎵撳紑鎽╂摝杞?    else
    {
        shoot_cmd_send.shoot_mode = SHOOT_OFF;
    }
     //宸﹁竟鎷ㄨ疆寰€涓婃墦鍒板簳锛屽紑濮嬪彂灏勫瓙寮? 
     if (rc_data[CURRENT].rc.dial > 450)
        {
            shoot_cmd_send.loader_mode = LOAD_BURSTFIRE;//杩炲彂
            shoot_cmd_send.shoot_rate = 8;//姣忓垎閽?0鍙?        }
        //姝ｅ父鎯呭喌涓嬩笉鍙戝皠瀛愬脊
        else
        {
            shoot_cmd_send.loader_mode = LOAD_STOP;     //
        }
    
    


    //姝ｅ父鎯呭喌涓嬩笉鍙戝皠瀛愬脊

    //鎬ュ仠妯″紡
    Emergency_stop();
    /****************鎺у埗閲忚瀹?****************/
    //搴曠洏鎺у埗閲?     /*鍚庣画鍙鍔犳鍖洪檺鍒讹紝瑙ｅ喅閬ユ帶鍣ㄩ€氶亾鍊煎洜鑰佸寲鑰岄€犳垚鐨勯浂婕傞棶棰?/
    if (rc_data[CURRENT].rc.Lrocker_y>=-32&&rc_data[CURRENT].rc.Lrocker_y<=0)
        chassis_cmd_send.vy=0;
    else {
        chassis_cmd_send.vy = 2.0f * (float)rc_data[CURRENT].rc.Lrocker_y; //绔栫洿鏂瑰悜
    }
    chassis_cmd_send.vx = 2.0f * (float)rc_data[CURRENT].rc.Lrocker_x; //姘村钩鏂瑰悜

    //浜戝彴鎺у埗閲?    gimbal_cmd_send.yaw += 0.005f * (float)rc_data[CURRENT].rc.Rrocker_x;
    gimbal_cmd_send.pitch += 0.01f * (float)(rc_data[CURRENT].rc.Rrocker_y);

    
   

}

/**
 * @brief 鎺у埗杈撳叆涓洪敭榧犵殑妯″紡鍜屾帶鍒堕噺璁剧疆
 *
*/
void Keyboard_ctrl_set()
{
     if (rc_data[CURRENT].rc.Rswitch == SWITCH_IS_DOWN)
    {
        chassis_cmd_send.chassis_mode = CHASSIS_FOLLOW_GIMBAL;
        gimbal_cmd_send.gimbal_mode = GIMBAL_GYRO_MODE; 
    }
    //濡傛灉鍙宠竟寮€鍏虫墦涓婏紝鍒欒繘鍏ュ簳鐩樿嚜鐢辨ā寮忥紝姝ゆ椂搴曠洏涓嶈窡闅忎簯鍙?    else if (rc_data[CURRENT].rc.Rswitch == SWITCH_IS_MID)
    {
        chassis_cmd_send.chassis_mode = CHASSIS_NO_FOLLOW;
        gimbal_cmd_send.gimbal_mode = GIMBAL_GYRO_MODE;  
    }
    //濡傛灉鍙宠竟寮€鍏虫墦涓棿锛屽垯搴曠洏杩涘叆灏忛檧铻烘ā寮忥紝浜戝彴杩涘叆鑷敱妯″紡
    else if (rc_data[CURRENT].rc.Rswitch == SWITCH_IS_UP)
    {
        chassis_cmd_send.chassis_mode = CHASSIS_ROTATE;
        gimbal_cmd_send.gimbal_mode = GIMBAL_GYRO_MODE;
    }
     /**灏勫嚮妯″紡璁惧畾**/
    //宸﹁竟鎷ㄨ疆寰€涓婃墦寮€鍚懇鎿﹁疆,杩涘叆鍑嗗灏勫嚮妯″紡
    if (rc_data[CURRENT].rc.dial > 150)
    {
        shoot_cmd_send.shoot_mode = SHOOT_ON;
    }
    //姝ｅ父鎯呭喌涓嬩笉鎵撳紑鎽╂摝杞?    else
    {
        shoot_cmd_send.shoot_mode = SHOOT_OFF;
    }
//姝ｅ父鎯呭喌涓嬩笉鍙戝皠瀛愬脊
  
    if (rc_data[CURRENT].rc.dial > 300 ){
        shoot_cmd_send.loader_mode =  LOAD_1_BULLET;//鍗曞彂
    }
  else
    {
        shoot_cmd_send.loader_mode = LOAD_STOP;     //
    }
    
    //鎬ュ仠妯″紡
    Emergency_stop();
    /****************鎺у埗閲忚瀹?****************/
    //搴曠洏鎺у埗閲?     /*鍚庣画鍙鍔犳鍖洪檺鍒讹紝瑙ｅ喅閬ユ帶鍣ㄩ€氶亾鍊煎洜鑰佸寲鑰岄€犳垚鐨勯浂婕傞棶棰?/
    if (rc_data[CURRENT].rc.Lrocker_y>=-32&&rc_data[CURRENT].rc.Lrocker_y<=0)
        chassis_cmd_send.vy=0;
    else {
        chassis_cmd_send.vy = 2.0f * (float)rc_data[CURRENT].rc.Lrocker_y; //绔栫洿鏂瑰悜
    }
    chassis_cmd_send.vx = 2.0f * (float)rc_data[CURRENT].rc.Lrocker_x; //姘村钩鏂瑰悜

    //浜戝彴鎺у埗閲?    gimbal_cmd_send.yaw += 0.005f * (float)rc_data[CURRENT].rc.Rrocker_x;
    gimbal_cmd_send.pitch += 0.01f * (float)(rc_data[CURRENT].rc.Rrocker_y);

    // 閿洏鎺у埗璁剧疆鐨勪复鏃跺疄鐜?    // 榛樿妯″紡璁剧疆
   // chassis_cmd_send.chassis_mode = CHASSIS_FOLLOW_GIMBAL;
    //gimbal_cmd_send.gimbal_mode = GIMBAL_GYRO_MODE;
   // shoot_cmd_send.shoot_mode = SHOOT_OFF;
   // shoot_cmd_send.loader_mode = LOAD_STOP;
    // 杩欓噷娣诲姞閿洏榧犳爣鐨勫叿浣撴帶鍒堕€昏緫

    // float yaw_delta = (float)rc_data[TEMP].mouse.x / 660.0f * 10.0f;
    // gimbal_cmd_send.yaw += yaw_delta;
    // gimbal_cmd_send.pitch += (float)rc_data[TEMP].mouse.y / 660.0f * 10.0f;

}

/**
 * @brief  绱ф€ュ仠姝?鍖呮嫭閬ユ帶鍣ㄥ乏涓婁晶鎷ㄨ疆鎵撴弧/閲嶈妯″潡绂荤嚎绛? *
 */
void Emergency_stop()
{
    // 鎷ㄨ疆鐨勫悜涓嬫墦鍒板簳鍒欒繘鍏ユ€ュ仠妯″紡
    if (rc_data[CURRENT].rc.dial < -300 || robot_state == ROBOT_OFF)
    {
        robot_state = ROBOT_OFF;
        gimbal_cmd_send.gimbal_mode = GIMBAL_ZERO_FORCE;
        chassis_cmd_send.chassis_mode = CHASSIS_ZERO_FORCE;
        shoot_cmd_send.shoot_mode = SHOOT_OFF;
        shoot_cmd_send.loader_mode = LOAD_STOP;
    }
    // 閬ユ帶鍣ㄥ彸渚у紑鍏充负[涓璢,鎭㈠姝ｅ父杩愯
    if (rc_data[CURRENT].rc.Rswitch == SWITCH_IS_MID)
    {
        robot_state = ROBOT_ON;
    }
}

/**
 * @brief 鏍规嵁gimbal浼犲洖鐨勫綋鍓嶇數鏈鸿搴﹁绠楀拰闆朵綅鐨勮宸? *        鍗曞湀缁濆瑙掑害鐨勮寖鍥存槸0~360
 *
 */
void Calc_offset_angle()
{
    // 濡傛灉鏈哄櫒浜哄浜庢€ュ仠鐘舵€侊紝涓嶈绠楀亸宸锛岀洿鎺ユ竻闆?    if (robot_state == ROBOT_OFF) {
        chassis_cmd_send.offset_angle = 0.0f;
        chassis_cmd_send.gimbal_yaw_total_angle = 0.0f;
        chassis_cmd_send.gimbal_yaw_rate = 0.0f;
        return;
    }
    
    // 鍒悕angle鎻愰珮鍙鎬?涓嶇劧澶暱浜嗕笉濂界湅,铏界劧鍩烘湰涓嶄細鍔ㄨ繖涓嚱鏁?    static float angle;
    static float last_offset_angle = 0.0f; // 璁板綍涓婁竴娆＄殑鍋忓樊瑙?    angle = gimbal_feedback_recv.yaw_motor_single_round_angle; // 浠庝簯鍙拌幏鍙栫殑褰撳墠yaw鐢垫満鍗曞湀瑙掑害
    
    float temp_offset_angle;
#if YAW_ECD_GREATER_THAN_4096                               // 濡傛灉澶т簬180搴?    if (angle > YAW_ALIGN_ANGLE && angle <= 180.0f + YAW_ALIGN_ANGLE)
        temp_offset_angle = angle - YAW_ALIGN_ANGLE;
    else if (angle > 180.0f + YAW_ALIGN_ANGLE)
        temp_offset_angle = angle - YAW_ALIGN_ANGLE - 360.0f;
    else
        temp_offset_angle = angle - YAW_ALIGN_ANGLE;
#else // 灏忎簬180搴?    if (angle > YAW_ALIGN_ANGLE)
        temp_offset_angle = angle - YAW_ALIGN_ANGLE;
    else if (angle <= YAW_ALIGN_ANGLE && angle >= YAW_ALIGN_ANGLE - 180.0f)
        temp_offset_angle = angle - YAW_ALIGN_ANGLE;
    else
        temp_offset_angle = angle - YAW_ALIGN_ANGLE + 360.0f;
#endif

    // 妫€娴嬭搴﹁烦鍙橈紝濡傛灉璺冲彉瓒呰繃180搴︼紝璇存槑鍙戠敓浜?/360搴﹁竟鐣岃法瓒?    float angle_diff = temp_offset_angle - last_offset_angle;
    if (angle_diff > 180.0f) {
        temp_offset_angle -= 360.0f;
    } else if (angle_diff < -180.0f) {
        temp_offset_angle += 360.0f;
    }
    
    // 闄愬埗鍋忓樊瑙掑湪-180鍒?80搴︿箣闂?    if (temp_offset_angle > 180.0f) {
        temp_offset_angle -= 360.0f;
    } else if (temp_offset_angle < -180.0f) {
        temp_offset_angle += 360.0f;
    }
    
    chassis_cmd_send.offset_angle = temp_offset_angle;
    last_offset_angle = temp_offset_angle;

    chassis_cmd_send.gimbal_yaw_total_angle = gimbal_feedback_recv.imu_yaw_total_angle;
    chassis_cmd_send.gimbal_yaw_rate = gimbal_feedback_recv.imu_yaw_rate;
}
